# OneKiwi RZ/V2H boards: U-Boot 2024.07 with onekiwi-rzv2h-* board support
UBOOT_URI:onekiwi-rzv2h-4gb = "git://github.com/OneKiwiEmbedded/renesas-rz-uboot-4.git;protocol=https"
UBOOT_URI:onekiwi-rzv2h-8gb = "git://github.com/OneKiwiEmbedded/renesas-rz-uboot-4.git;protocol=https"

UBOOT_BRANCH:onekiwi-rzv2h-4gb = "v2024.07/rz_dev_v2h"
UBOOT_BRANCH:onekiwi-rzv2h-8gb = "v2024.07/rz_dev_v2h"

UBOOT_REV:onekiwi-rzv2h-4gb = "${AUTOREV}"
UBOOT_REV:onekiwi-rzv2h-8gb = "${AUTOREV}"
