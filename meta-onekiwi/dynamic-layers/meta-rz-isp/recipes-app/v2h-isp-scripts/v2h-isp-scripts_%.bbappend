# meta-rz-isp restricts this recipe to rzv2h-evk. Allow the OneKiwi RZ/V2H boards too.
COMPATIBLE_MACHINE:onekiwi-rzv2h-4gb = "onekiwi-rzv2h-4gb"
COMPATIBLE_MACHINE:onekiwi-rzv2h-8gb = "onekiwi-rzv2h-8gb"
